options:
  parameters:
    generate_options: qt_gui
    id: testicompanion
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label: Uplink tallennus
    label0: File Sink
    label1: Null Sink
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: variable_qtgui_chooser_1
  id: variable_qtgui_chooser
  parameters:
    label: Downlink tallennus
    label0: File Sink
    label1: Null Sink
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: IF gain Uplink
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_0_1
  id: variable_qtgui_range
  parameters:
    label: VGA gain Downlink
    start: '0'
    step: '1'
    stop: '62'
    value: '0'
  states: {}
- name: variable_qtgui_range_1_0
  id: variable_qtgui_range
  parameters:
    label: IF gain Downlink
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: variable_qtgui_range_1_1
  id: variable_qtgui_range
  parameters:
    label: VGA gain Uplink
    rangeType: int
    start: '0'
    step: '1'
    stop: '62'
    value: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: downlink.cfile
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: uplink.cfile
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '2'
    output_index: variable_qtgui_chooser_0
    showports: 'False'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '2'
    output_index: variable_qtgui_chooser_1
    showports: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '5'
    fc: '0'
    fftsize: '1024'
    name: Downlink
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '5'
    fc: '0'
    fftsize: '1024'
    name: Uplink
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: '958.2'
    dev_args: '"0000000000000000147c63dc33993353"'
    gain: variable_qtgui_range_0
    samp_rate: '5000000'
    type: fc32
    vga: variable_qtgui_range_0_1
  states: {}
- name: soapy_hackrf_source_1
  id: soapy_hackrf_source
  parameters:
    center_freq: '903.2'
    dev_args: '"0000000000000000147c63dc33993353"'
    gain: variable_qtgui_range_1_0
    samp_rate: '5000000'
    type: fc32
    vga: variable_qtgui_range_1_1
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_selector_1, '1']
- [blocks_null_source_1, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_1, '0']
- [blocks_selector_1, '0', blocks_file_sink_1, '0']
- [blocks_selector_1, '1', blocks_null_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_selector_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_1, '0', blocks_selector_1, '0']
- [soapy_hackrf_source_1, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
